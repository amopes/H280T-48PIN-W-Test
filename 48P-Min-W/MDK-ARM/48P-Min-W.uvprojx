# Keil uVision project 48P-Min-W.uvprojx, settings and files
target 48P-Min-W (5060960::V5.06 update 7 (build 960)::.\Arm_Compiler_5.06u7)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 48P-Min-W +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Control/Logic_L;../Control/Driver_L;../Control/DEBUG;../Control/Electric_L;../Control/Sys;../Control/HGLS_Parts;../Control/Diagnose;../Control/Config
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c dma.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group SYS
    ../Control/Sys/: Sem_Queues.c Sem_Queues.h Sys_Cofig.h Sys_Cofig.c
    ../Control/Driver_L/: 220E_Dis_Pub_L.h
  group Logic_L
    ../Control/Logic_L/: Logic_Pub_L.c Logic_Pub_L.h
  group Driver_L
    ../Control/Driver_L/: BSP_48Pin_Pub_L.c BSP_48Pin_Pub_L.h
  group DEBUG
    ../Control/DEBUG/: DEBUG_Pub.c DEBUG_Pub.h DEBUG_UART.c common_fifo.c
  group Electric_L
    ../Control/Electric_L/: Electric_L_Pub.c Electric_L_Pub.h
  group HGLS_Parts
    ../Control/HGLS_Parts/: HPMotor.c HPMotor.h HGLS_Joy_Ped.c HGLS_Joy_Ped.h HGLS_7_appearance.c HGLS_7_appearance.h
  group Config
    ../Control/Config/: Config.c Config.h Computer_interface.c Computer_interface.h
  group Math
    ../Control/Sys/: Math.c Math.h
  group Diagnose
    ../Control/Diagnose/: Diagnose.c Diagnose.h
software components: CMSIS:CORE 5.6.0
